V1 1 0 2.5
V2 2 0 5.0
R1 3 1 1e3
R2 3 2 1e3
R3 4 0 1e3
R4 3 5 1e3
O1 4 3 5
